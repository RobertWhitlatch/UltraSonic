# Keil uVision project UltraSonic.uvproj, settings and files
target UltraSonic (ARM-ADS)
  device: TM4C1231C3PM Texas Instruments
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x7FFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Generic
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: .;.\include;.\driverlib_inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./src/: Interpreter.c UltraSonicMain.c UART1.c
  group Libraries
    ./driverlib_inc/: driverlib.lib
  group Environment
    ./src/: startup.s PLL.c main.c Output.c
